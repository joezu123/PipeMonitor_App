# IAR project Pipe_Monitor_App.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: HC32F460xE XHSC HC32F460xE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __DEBUG; HC32F460; USE_DEVICE_DRIVER_LIB
  ICCARM.CCIncludePath2: ..\..\..\..\..\mcu\common; ..\source; ..\..\..\..\..\driver\inc; ..\drv_device\drv_ADC; ..\drv_device\drv_IIC; ..\drv_device\drv_RTC; ..\drv_device\drv_SPI; ..\drv_device\drv_Timer; ..\drv_device\drv_USART; ..\source\4G_EC200U; ..\source\BT_TB05; ..\source\drv_LKT4202; ..\source\drv_SC7A20H; ..\source\drv_Storage_W25Q128; ..\source\LC86L_BD; ..\source\LoRa_RA02; ..\source\Magnetic_Bar; ..\source\Mainloop; ..\source\MQTT_SK; ..\source\OLED; ..\source\Photosensitive_XYC_ALS; ..\source\RF_NFC; ..\source\User_Data; ..\source\WatchDog; ..\source\ModbusRTU; ..\source\Lora-TP1109; ..\source\RF_NFC\RXNTTL518; ..\drv_device\drv_OTS_Temperature; ..\source\AlarmRule
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Pipe_Monitor_App.bin
  ILINK.IlinkOutputFile: Pipe_Monitor_App.out
  ILINK.IlinkIcfFile: HC32F460xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.FPU2: 0
  ICCARM.CCDefines: HC32F460; USE_DEVICE_DRIVER_LIB
  ICCARM.CCIncludePath2: ..\..\..\..\..\mcu\common; ..\source; ..\..\..\..\..\driver\inc; ..\..\..\..\..\bsp\ev_hc32f460_lqfp100_v2
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: adc_01_sa_base.srec
  ILINK.IlinkOutputFile: adc_01_sa_base.out
  ILINK.IlinkIcfFile: hc32f460xE.icf
  group (top)
    ../: Readme.txt
  group common
    ./: startup_hc32f460.s
    ../../../../../mcu/common/: system_hc32f460.c
  group driver
    ../../../../../driver/src/: hc32f460_adc.c hc32f460_clk.c hc32f460_dmac.c hc32f460_efm.c hc32f460_event_port.c hc32f460_exint_nmi_swi.c hc32f460_gpio.c hc32f460_i2c.c hc32f460_icg.c hc32f460_interrupts.c hc32f460_keyscan.c hc32f460_ots.c hc32f460_pwc.c hc32f460_rtc.c hc32f460_spi.c hc32f460_sram.c hc32f460_timer0.c hc32f460_timer4_cnt.c hc32f460_timer4_oco.c hc32f460_usart.c hc32f460_utility.c hc32f460_wdt.c
  group driver/drv_device/drv_ADC
    ../drv_device/drv_ADC/: drv_ADC.c
  group driver/drv_device/drv_IIC
    ../drv_device/drv_IIC/: drv_IIC.c
  group driver/drv_device/drv_RTC
    ../drv_device/drv_RTC/: drv_RTC.c
  group driver/drv_device/drv_SPI
    ../drv_device/drv_SPI/: drv_SPI.c
  group driver/drv_device/drv_Timer
    ../drv_device/drv_Timer/: drv_Timer.c
  group driver/drv_device/drv_USART
    ../drv_device/drv_USART/: drv_USART.c
  group driver/drv_OTS_Temperature
    ../drv_device/drv_OTS_Temperature/: drv_OTS_Temperature.c
  group source
    ../source/: main.c
  group source/4G_EC200U
    ../source/4G_EC200U/: 4G_EC200U.c
  group source/AlarmRule
    ../source/AlarmRule/: AlarmRule.c
  group source/BT_TB05
    ../source/BT_TB05/: BT_TB05.c
  group source/LC86L_BD
    ../source/LC86L_BD/: LC86L_BD.c
  group source/LKT4202
    ../source/drv_LKT4202/: drv_LKT4202.c
  group source/LoRa_RA02
    ../source/LoRa_RA02/: LoRa_RA02.c
  group source/Lora_TP1109
    ../source/Lora-TP1109/: Lora_TP1109.c Lora_TP1109.h
  group source/Magnetic_Bar
    ../source/Magnetic_Bar/: Magnetic_Bar.c
  group source/Mainloop
    ../source/Mainloop/: Mainloop.c
  group source/ModbusRTU
    ../source/ModbusRTU/: ModbusRTU.c ModbusRTU_Device_BT.c
  group source/MQTT_SK
    ../source/MQTT_SK/: MQTT_SK.c
  group source/OLED
    ../source/OLED/: Display.c Font.c OLED.c
  group source/Photosensitive_XYC_ALS
    ../source/Photosensitive_XYC_ALS/: Photosensitive_XYC_ALS.c
  group source/RF_NFC
    ../source/RF_NFC/: fm175xx.c mifare_card.c RF_NFC.c type_a.c type_b.c
  group source/RF_NFC/RXNTTL518
    ../source/RF_NFC/RXNTTL518/: RXNTTL518.c RXNTTL518.h
  group source/SC7A20H
    ../source/drv_SC7A20H/: drv_SC7A20H.c
  group source/Storage_W25Q128
    ../source/drv_Storage_W25Q128/: drv_Storage_W25Q128.c
  group source/User_Data
    ../source/User_Data/: User_Data.c
  group source/WatchDog
    ../source/WatchDog/: WatchDog.c
